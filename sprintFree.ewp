# IAR project sprintFree.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F303K8 ST STM32F303K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: C:\FW\sprintFree; C:\FW\sprintFree\st
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sprintFree.srec
  ILINK.IlinkOutputFile: sprintFree.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    src/: main.cpp
  group st
    st/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h startup_stm32f303x8.s stm32f303x8.h stm32f3xx.h system_stm32f3xx.c system_stm32f3xx.h
